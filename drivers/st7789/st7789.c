// st7789: شاشة TFT ملوّنة عبر SPI بدون مخزن إطار كامل (بث أشرطة RGB565)
// cfg: cs=7, dc=2, rst=-1, bl=-1, width=240, height=240, xoff=0, yoff=0, freq=20000000
// الدوال: clear([color]) · pixel(x,y,color) · rect(x,y,w,h,color) · text(x,y,str[,color,bg]) · backlight(on) · invert(on)
#include "drvrt.h"

typedef struct {
  const drv_api_t* api;
  uint8_t* line;
  uint32_t freq;
  uint16_t w, h, xoff, yoff;
  uint8_t cs, dc, mode;
  int8_t rst, bl;
} Tft;

static const char NAME[] = "st7789";

static const uint8_t FONT5X7[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
  {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
  {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
  {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
  {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
  {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
  {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
  {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
  {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
  {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
  {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
  {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
  {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
  {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
  {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
  {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},
  {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x10,0x08,0x08,0x10,0x08}
};

static int wr_cmd(Tft* t, uint8_t c) {
  t->api->gpio_write(t->dc, 0);
  return t->api->spi_write(t->cs, t->freq, t->mode, &c, 1);
}
static int wr_data(Tft* t, const uint8_t* d, size_t n) {
  t->api->gpio_write(t->dc, 1);
  return t->api->spi_write(t->cs, t->freq, t->mode, d, n);
}
static int set_win(Tft* t, uint16_t x0, uint16_t y0, uint16_t x1, uint16_t y1) {
  x0 += t->xoff; x1 += t->xoff; y0 += t->yoff; y1 += t->yoff;
  uint8_t bx[4] = { (uint8_t)(x0 >> 8), (uint8_t)x0, (uint8_t)(x1 >> 8), (uint8_t)x1 };
  uint8_t by[4] = { (uint8_t)(y0 >> 8), (uint8_t)y0, (uint8_t)(y1 >> 8), (uint8_t)y1 };
  int e = wr_cmd(t, 0x2A); if (e) return e;
  e = wr_data(t, bx, 4); if (e) return e;
  e = wr_cmd(t, 0x2B); if (e) return e;
  e = wr_data(t, by, 4); if (e) return e;
  return wr_cmd(t, 0x2C);
}
static int fill_rect(Tft* t, uint16_t x, uint16_t y, uint16_t w, uint16_t h, uint16_t color) {
  int e = set_win(t, x, y, (uint16_t)(x + w - 1), (uint16_t)(y + h - 1));
  if (e) return e;
  uint8_t hi = (uint8_t)(color >> 8), lo = (uint8_t)(color & 0xFF);
  for (uint16_t i = 0; i < w; i++) { t->line[2 * i] = hi; t->line[2 * i + 1] = lo; }
  t->api->gpio_write(t->dc, 1);
  for (uint16_t row = 0; row < h; row++) {
    e = t->api->spi_write(t->cs, t->freq, t->mode, t->line, (size_t)w * 2);
    if (e) return e;
  }
  return 0;
}

static int do_open(void** ctx, const drv_api_t* api, const drv_kv_t* cfg, int n) {
  if (!api->spi_write || !api->gpio_mode || !api->gpio_write) return 1;
  int w = drv_cfg_int(cfg, n, "width", 240);
  int h = drv_cfg_int(cfg, n, "height", 240);
  if (w < 42 || w > 320 || h <= 0 || h > 320) return DRV_E_ARGS;   // 42 بكسل على الأقل ليتسع شريط الحرف
  Tft* t = (Tft*)api->alloc(sizeof(Tft));
  if (!t) return 1;
  t->line = (uint8_t*)api->alloc((size_t)w * 2);
  if (!t->line) { api->release(t); return 1; }
  t->api = api;
  t->w = (uint16_t)w; t->h = (uint16_t)h;
  t->xoff = (uint16_t)drv_cfg_int(cfg, n, "xoff", 0);
  t->yoff = (uint16_t)drv_cfg_int(cfg, n, "yoff", 0);
  t->cs = (uint8_t)drv_cfg_int(cfg, n, "cs", 7);
  t->dc = (uint8_t)drv_cfg_int(cfg, n, "dc", 2);
  t->rst = (int8_t)drv_cfg_int(cfg, n, "rst", -1);
  t->bl = (int8_t)drv_cfg_int(cfg, n, "bl", -1);
  t->freq = (uint32_t)drv_cfg_int(cfg, n, "freq", 20000000);
  t->mode = (uint8_t)drv_cfg_int(cfg, n, "mode", 0);

  // الدبابيس تُحجز لسكريبت المستدعي؛ إن كان أحدها مملوكًا لغيره يفشل الفتح
  int pe = api->gpio_mode(t->dc, 1);
  if (!pe && t->rst >= 0) {
    pe = api->gpio_mode((uint8_t)t->rst, 1);
    if (!pe) { api->gpio_write((uint8_t)t->rst, 0); api->delay_ms(20); api->gpio_write((uint8_t)t->rst, 1); api->delay_ms(120); }
  }
  if (!pe && t->bl >= 0) { pe = api->gpio_mode((uint8_t)t->bl, 1); if (!pe) api->gpio_write((uint8_t)t->bl, 1); }
  if (pe) { api->release(t->line); api->release(t); return pe; }

  int e = wr_cmd(t, 0x01); if (e) { api->release(t->line); api->release(t); return e; }
  api->delay_ms(120);
  wr_cmd(t, 0x11); api->delay_ms(120);
  uint8_t colmod = 0x55; wr_cmd(t, 0x3A); wr_data(t, &colmod, 1);
  uint8_t madctl = 0x00; wr_cmd(t, 0x36); wr_data(t, &madctl, 1);
  wr_cmd(t, 0x21); // IPS inversion on
  wr_cmd(t, 0x29); // display on
  *ctx = t;
  return 0;
}

static void do_close(void* ctx) {
  Tft* t = (Tft*)ctx;
  wr_cmd(t, 0x28);
  if (t->bl >= 0) t->api->gpio_write((uint8_t)t->bl, 0);
  t->api->release(t->line);
  t->api->release(t);
}

static int m_clear(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)r; (void)nr;
  Tft* t = (Tft*)ctx;
  uint16_t c = na >= 1 ? (uint16_t)a[0].v.i : 0x0000;
  return fill_rect(t, 0, 0, t->w, t->h, c);
}
static int m_pixel(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)na; (void)r; (void)nr;
  Tft* t = (Tft*)ctx;
  int x = a[0].v.i, y = a[1].v.i;
  if (x < 0 || x >= t->w || y < 0 || y >= t->h) return DRV_E_ARGS;
  return fill_rect(t, (uint16_t)x, (uint16_t)y, 1, 1, (uint16_t)a[2].v.i);
}
static int m_rect(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)na; (void)r; (void)nr;
  Tft* t = (Tft*)ctx;
  int x = a[0].v.i, y = a[1].v.i, w = a[2].v.i, h = a[3].v.i;
  if (x < 0 || y < 0 || w <= 0 || h <= 0 || x + w > t->w || y + h > t->h) return DRV_E_ARGS;
  return fill_rect(t, (uint16_t)x, (uint16_t)y, (uint16_t)w, (uint16_t)h, (uint16_t)a[4].v.i);
}
static int m_text(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)r; (void)nr;
  Tft* t = (Tft*)ctx;
  int x = a[0].v.i, y = a[1].v.i;
  uint16_t fg = na >= 4 ? (uint16_t)a[3].v.i : 0xFFFF;
  uint16_t bg = na >= 5 ? (uint16_t)a[4].v.i : 0x0000;
  if (x < 0 || y < 0 || y + 7 > t->h) return DRV_E_ARGS;
  const char* s = a[2].v.s;
  for (int k = 0; k < a[2].len && x + 6 <= t->w; k++) {
    unsigned char ch = (unsigned char)s[k];
    if (ch < 32 || ch > 126) ch = '?';
    const uint8_t* g = FONT5X7[ch - 32];
    int e = set_win(t, (uint16_t)x, (uint16_t)y, (uint16_t)(x + 5), (uint16_t)(y + 6));
    if (e) return e;
    for (int row = 0; row < 7; row++) {
      for (int col = 0; col < 6; col++) {
        uint16_t c = (col < 5 && ((g[col] >> row) & 1)) ? fg : bg;
        int idx = (row * 6 + col) * 2;
        t->line[idx] = (uint8_t)(c >> 8);
        t->line[idx + 1] = (uint8_t)(c & 0xFF);
      }
    }
    e = wr_data(t, t->line, 6 * 7 * 2);
    if (e) return e;
    x += 6;
  }
  return 0;
}
static int m_backlight(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)na; (void)r; (void)nr;
  Tft* t = (Tft*)ctx;
  if (t->bl >= 0) t->api->gpio_write((uint8_t)t->bl, a[0].v.i ? 1 : 0);
  return 0;
}
static int m_invert(void* ctx, const drv_val_t* a, int na, drv_val_t* r, int* nr) {
  (void)na; (void)r; (void)nr;
  return wr_cmd((Tft*)ctx, a[0].v.i ? 0x21 : 0x20);
}

static const drv_method_t METHODS[] = {
  { "clear",     "I",     m_clear },
  { "pixel",     "iii",   m_pixel },
  { "rect",      "iiiii", m_rect },
  { "text",      "iisII", m_text },
  { "backlight", "b",     m_backlight },
  { "invert",    "b",     m_invert },
};

static const drv_ops_t OPS = { DRV_API_VERSION, NAME, "ST7789 color TFT strip renderer (SPI)", METHODS, 6, do_open, do_close };
DRV_EXPORT const drv_ops_t* drv_entry(void) { return &OPS; }
